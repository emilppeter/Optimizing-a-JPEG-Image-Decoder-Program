# Keil uVision project LCDs_Profiler.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: LCDs_Profiler
  AfterMake: Scripts\update_regions_MDK.bat !L
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Include;.\Source\Profiler;.\Source\LCD
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source Group 1
    ./Source/: delay.c LEDs.c main.c MMA8451.c debug.c I2C.c timers.c UART.c queue.c
  group Profiler
    ./Source/Profiler/: profile.c region.c PIT.c
  group LCD
    ./Source/LCD/: LCD_JPEG.c LCD_graphics.c LCD_text.c lucida_8x13.c lucida_12x19.c ST7789.c touchscreen.c picojpeg.c JPEG_image.c colors.c
software components: CMSIS:CORE 5.0.2, Device:Startup 2.5.0
